Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2023-08-30T15:45:51
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 23.0.13600.0000 - Exporter 19.0.0.401 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Aug 30 15:45:51 2023 * Host: LB-HPLAPTOP-05 * Database: C:\Users\ALEXBR~1\AppData\Local\Temp\{140FBA36-78F7-4287-BA53-DF7E43F634FE}\ifc * Database version: 5507 * Database creation date: Wed Aug 30 15:45:49 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Aug 30 15:45:50 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Aug 30 15:45:50 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcBuildingElementProxy: Standard, Family1:Standard:201878
In: Level 1
Type - Material: Brass - Satin, Smooth - White
Type - Identity Data - Type Name: Standard
Type - Other - Category: Generic Models; Family Name: Family1
Pset_BuildingElementProxyCommon - Reference: Standard
Constraints - Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 0.178428 m2; Volume: 0.00073946 m3
Other - Family: Family1: Standard; Family and Type: Family1: Standard; Type: Family1: Standard; Type Id: Family1: Standard
Phasing - Phase Created: New Construction
